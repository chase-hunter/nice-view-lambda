## boards/shields/nice_view_lambda/Kconfig.shield
```kconfig
config SHIELD_NICE_VIEW_LAMBDA
    def_bool $(shields_list_contains,nice_view_lambda)
```
